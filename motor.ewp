# IAR project motor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx7xx TexasInstruments LM3Sx7xx
  ICCARM.CCDefines: ewarm; PART_LM3S3748; TARGET_IS_DUSTDEVIL_RA0; IAR_ARMCM3_LM; CYGWIN=0; REGRESS_2=1
  ICCARM.CCIncludePath2: c:\dev\docs\rtos\freertos\FreeRTOS\Source\include; c:\dev\docs\rtos\freertos\FreeRTOS\Demo\CORTEX_LM3Sxxxx_IAR_Keil; c:\dev\docs\rtos\freertos\FreeRTOS\Source\portable\IAR\ARM_CM3; c:\dev\docs\rtos\freertos\FreeRTOS\Demo\Common\drivers\LuminaryMicro; c:\dev\docs\rtos\freertos\FreeRTOS\Demo\Common\include; c:\DriverLib; c:\dev\docs\scottdesign\parser; c:\dev\docs\scottdesign\motor
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: c:\dev\docs\rtos\freertos\FreeRTOS\Demo\CORTEX_LM3Sxxxx_IAR_Keil
  ILINK.IlinkOutputFile: motor.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; ewarm; PART_LM3S3748; TARGET_IS_DUSTDEVIL_RA0; IAR_ARMCM3_LM; CYGWIN=0; REGRESS_2=1; BISON_IAR=1
  ICCARM.CCDiagSuppress: Pa050, Pe111
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: motor.bin
  group Libraries
    ../../../../DriverLib/src/ewarm/Exe/: driverlib.a
    ../../../../DriverLib/grlib/ewarm/Exe/: grlib.a
  group Scheduler
    ../../rtos/freertos/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../rtos/freertos/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../rtos/freertos/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Source
    ./: accel.cpp main.c motor.cpp stepper.cpp
    ../../../../DriverLib/boards/ek-lm3s3748/: formike128x128x16.c
    ../parser/: interpret.cpp motor.tab.c parseTreeEntry.cpp symbolTableEntry.cpp
    ../../rtos/freertos/FreeRTOS/Demo/Common/Minimal/: IntQueue.c
    ../../rtos/freertos/FreeRTOS/Demo/CORTEX_LM3Sxxxx_IAR_Keil/: IntQueueTimer.c timertest.c
    ../../../../DriverLib/boards/ek-lm3s3748/motor/: startup_ewarm.c
