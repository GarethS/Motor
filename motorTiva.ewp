# IAR project motorTiva.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120C4QR TexasInstruments LM4F120C4QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C1233D5PM; TARGET_IS_BLIZZARD_RB1; UART_BUFFERED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..\..\..; C:\ti\TivaWare_C_Series-1.0; C:\ti\TivaWare_C_Series-1.0\inc; C:\ti\TivaWare_C_Series-1.0\examples\boards\ek-tm4c123gxl\usb_dev_serial; ..\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\FreeRTOS; ..\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  AARM.AUserIncludes: $PROJ_DIR$; ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: motorTiva.bin
  ILINK.IlinkOutputFile: motorTiva.out
  ILINK.IlinkIcfFile: motorTiva.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../ti/TivaWare_C_Series-1.0/driverlib/ewarm/Exe/: driverlib.a
    ../../../../ti/TivaWare_C_Series-1.0/usblib/ewarm/Exe/: usblib.a
  group Source
    ./: accel.cpp flashio.cpp main.c startup_ewarm.c stepper.cpp usb_dev_serial.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../parser/: interpret.cpp parseTreeEntry.cpp symbolTableEntry.cpp
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../../../../ti/TivaWare_C_Series-1.0/utils/: uartstdio.c ustdlib.c
    ../../../../ti/TivaWare_C_Series-1.0/examples/boards/ek-tm4c123gxl/usb_dev_serial/: usb_serial_structs.c
